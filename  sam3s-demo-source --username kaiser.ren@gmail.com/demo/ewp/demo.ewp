# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3s4; flash; USE_IAP_FEATURE; SAM_PORTING=1; TRACE_LEVEL=3
  ICCARM.PreInclude: ..\..\libraries\board\at91sam3s4\AT91SAM3S4.h
  ICCARM.CCIncludePath2: ..\..\libraries\; ..\..\libraries\board\; ..\..\libraries\cmsis\; ..\..\libraries\drivers\; ..\..\libraries\memories\; ..\..\libraries\fat\fatfs\src\; ..\..\libraries\components\; ..\..\libraries\sam-gui\; ..\src\; ..\src\nand\; ..\src\lcd\; ..\src\qtouch\; ..\src\freertos\; ..\src\freertos\include\; ..\src\freertos\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\freertos\
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\demo\ewp\mapping\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../src/: board_dependencies.c board_dependencies.h demo_parameters.c demo_parameters.h fatfs_config.h main.c
  group at91lib/board/at91sam3s4
    ../../libraries/board/at91sam3s4/: AT91SAM3S4.h
  group at91lib/cmsis
    ../../libraries/cmsis/: core_cm3.c core_cm3.h
  group at91lib/components/ads7843
    ../../libraries/components/ads7843/: ads7843.c ads7843.h
  group at91lib/drivers/acc
    ../../libraries/drivers/acc/: acc.c acc.h
  group at91lib/drivers/adc
    ../../libraries/drivers/adc/: adc.c adc.h
  group at91lib/drivers/crccu
    ../../libraries/drivers/crccu/: crccu.c crccu.h
  group at91lib/drivers/dacc
    ../../libraries/drivers/dacc/: dacc.c dacc.h
  group at91lib/drivers/efc
    ../../libraries/drivers/efc/: efc.c efc.h
  group at91lib/drivers/flash
    ../../libraries/drivers/flash/: flashd.c flashd.h
  group at91lib/drivers/lcd
    ../../libraries/drivers/lcd/: color.h draw.c draw.h font.c font.h font10x14.h lcdd.c lcdd.h
  group at91lib/drivers/pio
    ../../libraries/drivers/pio/: pio.c pio.h pio_it.c pio_it.h pio_keypad.c pio_keypad.h
  group at91lib/drivers/pmc
    ../../libraries/drivers/pmc/: pmc.c pmc.h
  group at91lib/drivers/pwmc
    ../../libraries/drivers/pwmc/: pwmc.c pwmc.h
  group at91lib/drivers/qtouch
    ../../libraries/drivers/qtouch/: libQTouchIarCfg3SRevABeta1.a libQTouchIarCfg3SRevABeta2.a libQTouchIarCfg3SRevB.a
  group at91lib/drivers/rtc
    ../../libraries/drivers/rtc/: rtc.c rtc.h
  group at91lib/drivers/rtt
    ../../libraries/drivers/rtt/: rtt.c rtt.h
  group at91lib/drivers/spi
    ../../libraries/drivers/spi/: spi.c spi.h
  group at91lib/drivers/tc
    ../../libraries/drivers/tc/: tc.c tc.h
  group at91lib/drivers/usart
    ../../libraries/drivers/usart/: uart_console.c uart_console.h usart.c usart.h
  group at91lib/drivers/utility
    ../../libraries/drivers/utility/: assert.h bitbanding.h bmp.c bmp.h clock.h hamming.c hamming.h iap.c iap.h led.c led.h math.c math.h rand.c rand.h stdio.c string.c trace.c trace.h util.c util.h video.c video.h wav.c wav.h
  group at91lib/drivers/utility/encryption
    ../../libraries/drivers/utility/encryption/: aes_hardware.c aes_hardware.h aes_reference.c aes_reference.h encryption.h libtomcrypt.c libtomcrypt.h tdes_hardware.c tdes_hardware.h
  group at91lib/drivers/wdt
    ../../libraries/drivers/wdt/: wdt.c wdt.h
  group at91lib/fat/fatfs/src
    ../../libraries/fat/fatfs/src/: diskio.c diskio.h ff.c ff.h integer.h
  group at91lib/fat/fatfs/src/option
    ../../libraries/fat/fatfs/src/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c syncobj.c
  group at91lib/memories
    ../../libraries/memories/: Media.c Media.h MEDNandFlash.c MEDNandFlash.h
  group at91lib/memories/nandflash
    ../../libraries/memories/nandflash/: EccNandFlash.c EccNandFlash.h ManagedNandFlash.c ManagedNandFlash.h MappedNandFlash.c MappedNandFlash.h NandCommon.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h TranslatedNandFlash.c TranslatedNandFlash.h
  group at91lib/sam-gui/common
    ../../libraries/sam-gui/common/: sam_gui_bitmap_raw.c sam_gui_bitmap_raw.h sam_gui_color.c sam_gui_color.h sam_gui_colors.c sam_gui_colors.h sam_gui_errors.h sam_gui_font.c sam_gui_font.h sam_gui_font10x14.c sam_gui_font10x14.h sam_gui_point.c sam_gui_point.h sam_gui_size.c sam_gui_size.h
  group at91lib/sam-gui/disp
    ../../libraries/sam-gui/disp/: disp_backend.c disp_backend.h
  group at91lib/sam-gui/disp/backends/HX8347
    ../../libraries/sam-gui/disp/backends/HX8347/: backend_HX8347.c backend_HX8347.h
  group at91lib/sam-gui/disp/backends/ILI9325
    ../../libraries/sam-gui/disp/backends/ILI9325/: backend_ILI9325.c backend_ILI9325.h
  group at91lib/sam-gui/docs
    ../../libraries/sam-gui/docs/: pcx.txt
  group at91lib/sam-gui/file
    ../../libraries/sam-gui/file/: file_fs.h
  group at91lib/sam-gui/porting
    ../../libraries/sam-gui/porting/: sam_gui_embos.c sam_gui_freertos.c sam_gui_nuttx.c sam_gui_porting.h
  group at91lib/sam-gui/wgt/core
    ../../libraries/sam-gui/wgt/core/: wgt_core.c wgt_core.h wgt_core_behaviour.c wgt_core_behaviour.h wgt_core_behaviour_default.c wgt_core_frontend.c wgt_core_frontend.h wgt_core_message.c wgt_core_message.h wgt_core_pointer.c wgt_core_pointer.h wgt_core_screen.c wgt_core_screen.h wgt_core_timer.c wgt_core_timer.h wgt_core_widget.c wgt_core_widget.h
  group at91lib/sam-gui/wgt/frontends
    ../../libraries/sam-gui/wgt/frontends/: frontend_ADS7843.c frontend_ADS7843.h frontend_potentiometer.c frontend_potentiometer.h frontend_pushbuttons.c frontend_pushbuttons.h frontend_qtouch.c frontend_qtouch.h
  group at91lib/usb/common/core
    ../../libraries/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceAssociationDescriptor.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/device/core
    ../../libraries/usb/device/core/: USBD.h USBD_UDP.c USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h
  group at91lib/usb/device/massstorage
    ../../libraries/usb/device/massstorage/: MSD.h MSDDriver.c MSDDriver.h MSDDriverDescriptors.c MSDDriverDescriptors.h MSDDStateMachine.c MSDDStateMachine.h MSDIOFifo.c MSDIOFifo.h MSDLun.c MSDLun.h SBC.h SBCMethods.c SBCMethods.h
  group bitmaps
    ../src/bitmaps/: bitmaps.h
  group bitmaps/excluded
    ../src/bitmaps/: bmp_config_backlight.c bmp_intro_sam3s_ek.c bmp_logo_atmel.c bmp_under_construction.c btn_audio.c btn_back.c btn_infos.c btn_low_power_modes.c btn_qt_down.c btn_qtouch.c btn_settings.c btn_slideshow.c btn_video.c lena128x128x24.c lena128x128x24clr.c lena128x128x8.c lena256x256x8.c
  group demo GUI
    ../src/gui/: scr_audio.c scr_disp_demo.c scr_infos.c scr_intro.c scr_lp_modes.c scr_lp_modes_backup.c scr_lp_modes_sleep.c scr_lp_modes_wait.c scr_main.c scr_ppt.c scr_qtouch.c scr_settings.c scr_settings_backlight.c scr_settings_date.c scr_settings_time.c scr_TSDCalibration.c screens.h
  group documentation
    ../../admin/doxygen/: Doxyfile
  group freertos
    ../src/freertos/: croutine.c FreeRTOSConfig.h list.c queue.c tasks.c
    ../src/freertos/portable/MemMang/: heap_1.c heap_2.c heap_3.c
  group freertos/bsp
    ../../libraries/board/: board.h board_cstartup_iar.c board_memories.h exceptions.c exceptions.h
    ../src/: board_lowlevel_demo.c board_lowlevel_demo.h board_memories_demo.c board_memories_demo.h
  group freertos/include
    ../src/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
  group freertos/port_SAM3
    ../src/freertos/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group mapping
    mapping/: flash.icf
  group nand
    ../src/nand/: ftldrv.c ftldrv.h MSDLun.c MSDLun.h rtmedia.c rtmedia.h
  group qtouch
    ../src/qtouch/: compiler.h compiler_arm_iar.h qtouch.c qtouch.h touch_api.h
  group usb
    ../src/usb/: usbmsd.c usbmsd.h
